## drivers/platform/xiaomi/Kconfig
```kconfig
# Xiaomi newcam option

config XIAOMI_NEW_CAMERA
        bool "Xiaomi new camera blobs"
        help
          Support for new camera blobs
```
